# Keil uVision project MBIOT_BloodPressure.uvproj, settings and files
target Release_Mode (MCS-51)
  device: W77E58 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x3FF) CLOCK(40000000)MODDP2
  output: BloodPressure_Release +hex
  AfterMake: ".\Tools\Release_Mode\Rehex_Generates_Shadowed_BIN.bat"
  c flags: Optimize=9
  c define: BT5505,BT_LE_IMPLE,BLE_SINGLE_MODE,MBIOT
  c include: ..\..\Include;..\..\Include\BLE;..\..\Include\BLE_Service;..\..\Include\Common;..\..\Include\Peripheral;..\BloodPressure
  asm define: BT5505=1,BLE_SINGLE_MODE=1,BT_LE_IMPLE=1,MBIOT=1
  group Application
    ../../Source/: eflash_permission_key.c
    ./: application.c
    ../../Source/BLE_Service/: ble_blood_pressure_service.c
  group MBIoT_LIBs
    ../../LIBs/: MBIOT_LIB0.LIB MBIOT_LIB1.LIB MBIOT_LIB2.LIB MBIOT_LIB3.LIB MBIOT_LIB4.LIB MBIOT_LIB5.LIB MBIOT_LIBC.LIB
  group CLib
    ../../Source/: C51S.LIB C51FPL.LIB
