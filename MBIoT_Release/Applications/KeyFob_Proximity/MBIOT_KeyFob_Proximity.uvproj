# Keil uVision project MBIOT_KeyFob_Proximity.uvproj, settings and files
target Release_Mode (MCS-51)
  device: W77E58 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x3FF) CLOCK(40000000)MODDP2
  output: KeyFob_Proximity_Release +hex
  AfterMake: ".\Tools\Release_Mode\Rehex_Generates_Shadowed_BIN.bat"
  c flags: Optimize=9
  c define: BT5505,BT_LE_IMPLE,BLE_SINGLE_MODE,MBIOT
  c include: ..\..\..\Assemble_Lib;..\..\..\8051Core;..\..\..\BTCore\;..\..\..\Interface_ISR\;..\..\..\LowLayer_BBLC\;..\..\..\LowLayer_CTC\;..\..\..\LowLayer_DataBase\;..\..\..\LowLayer_HCI\;..\..\..\LowLayer_LMP\;..\..\..\Main\;..\..\..\Power_Control\;..\..\..\Product\;..\..\..\RF_Module\;..\..\..\RTOS\;..\..\..\BLE_UpLayer\;..\..\..\UpLayer_L2CAP\;..\..\..\BLE_Sniffer\;..\..\..\UpLayer_Application\;..\..\..\Main_utility\;..\..\..\UpLayer_SMP\;..\..\..\UpLayer_ATT\;..\..\..\Fixed_CommonBank\;..\..\..\Boot\;..\..\..\BLE_Adapter\;..\..\..\BLE_AirPatch\;..\..\..\Common\;..\..\..\Peripheral\;..\..\Include;..\..\Include\BLE;..\..\Include\BLE_Service;..\..\Include\Common;..\..\Include\Peripheral;..\AutoPattern
  asm define: BT5505=1,BLE_SINGLE_MODE=1,BT_LE_IMPLE=1,MBIOT=1
  asm include: ..\..\..\8051Core;..\..\..\Product
  group Application
    ../../Source/: eflash_permission_key.c
    ./: application.c
    ../../Source/BLE_Service/: ble_alert_notify_service.c ble_immediate_alert_service.c ble_link_loss_service.c ble_tx_power_service.c
  group MBIoT_LIBs
    ../../LIBs/: MBIOT_LIB0.LIB MBIOT_LIB1.LIB MBIOT_LIB2.LIB MBIOT_LIB3.LIB MBIOT_LIB4.LIB MBIOT_LIB5.LIB MBIOT_LIBC.LIB
  group CLib
    ../../Source/: C51S.LIB C51FPL.LIB
